## l6/l6_e1/Kconfig
```kconfig
source "Kconfig.zephyr"

config CONFIG_BMP280
    bool "Use BMP280"
    default n
```
